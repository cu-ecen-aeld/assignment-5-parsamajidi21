## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  Uses to building and installing misc-modules and scull components to the root filesystem.
```
